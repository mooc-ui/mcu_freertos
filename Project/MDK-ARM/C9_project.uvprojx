# Keil uVision project C9_project.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: V85XX Generic
  pack: Vango.V85XX.4.0.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: c9_project +hex
  AfterMake: F:\qsport_code\mcu_freertos\tool\generateLstFile.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_TARGET_DRIVER
  c include: ..\Inc;..\Src;..\..\Libraries\Lib_Driver\inc;..\..\Libraries\\Lib_Driver\src;..\..\Libraries\CMSIS\device;..\..\Libraries\CMSIS\include;..\Src\FreeRTOS\include;..\Src\FreeRTOS\portable\RVDS\ARM_CM0;..\Src\SEGGER_RTT_V640\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Template/User
    ../Src/: main.c target_isr.c user.c key.c adc.c delay.c crc.c motor_ctrl.c uart.c v_stdio.c dwinScreenDriver.c dwinScreenDriver.h chargePedestal.c chargePedestal.h battery.c battery.h highSpeedMotor.c highSpeedMotor.h floorBrushPump.c floorBrushPump.h floorBrushMotor.c floorBrushMotor.h hardwareTimer.c hardwareTimer.h button.c button.h
    ../Inc/: lib_conf.h
  group Template/MDK-ARM
    ./: startup_target.s
  group FWLib
    ../../Libraries/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_comp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
  group FWLib/Device
    ../../Libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
  group freeRTOS
    ../Src/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Src/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../Src/FreeRTOS/portable/MemMang/: heap_4.c
  group seggerRtt
    ../Src/SEGGER_RTT_V640/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Application
    ../Src/: taskManage.c taskManage.h
software components: CMSIS:CORE 4.1.0
